IMAGE_INSTALL += " rgb2yuv-c"
