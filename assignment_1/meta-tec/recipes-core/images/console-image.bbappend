IMAGE_INSTALL += " rgb2yuv-neon"
